## ultrasonik/Config.in
```kconfig
config BR2_PACKAGE_ULTRASONIK
    bool "ultrasonik module"
    help
      Simple device module
```
